# Keil uVision project kingsky.uvproj, settings and files
target Target 1 (MCS-51)
  device: T89C51RD2 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0xFFFF)  XRAM (0-0x3FF)  CLOCK(40000000) MODP2
  output: kingsky +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./Source/: main.c
    ./uCosii/: ks_core.c ks_cpu.c ks_mutex.c ks_queue.c ks_sem.c ks_thread.c ks_cpu_a.asm
    ./: STARTUP.A51
